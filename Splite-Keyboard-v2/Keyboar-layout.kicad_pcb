# Repository ncwhale/Keyboard_Design

File README.md:

# Keyboard Designs

My keyboard designs. Free to use it in your project.

[中文版本](README.zh_CN.md)

# Splite Keyboard version 3

This is my current design. 

Layout updated for more suitable left/right hand usage.

Details in [V3 README.md](Splite-Keyboard-v3/README.md)

# Splite Keyboard version 2

    Sorry for the typo of filename...but that's why I need to build new keyboard (this project): my HHKB did not work perfect when weather changed frequently, and key missing happened a lot.

# Folder layout

* `${project name}-${version}` : keyboard design files, include KiCad/Layout/XML/JSON... 
* `${project name}-${version}.output` : factory product files. PCB/CNC/3D Print...

[MIT License](LICENSE)

## KiCad design Splite-Keyboard-v2/Keyboar-layout.kicad_pcb

Parts:
D1, D2: IIC_OLED
D_1, D_2, D_3, D_4, D_5, D_6, D_7, D_8, D_9, D_10: D; D_SOD123_axial
D_A1: D; D_SOD123_axial
D_ALT1: D; D_SOD123_axial
D_B1: D; D_SOD123_axial
D_BS1: D; D_SOD123_axial
D_C1: D; D_SOD123_axial
D_CONTROL1: D; D_SOD123_axial
D_D1: D; D_SOD123_axial
D_DEL1: D; D_SOD123_axial
D_E1: D; D_SOD123_axial
D_ENTER1: D; D_SOD123_axial
D_ESC1: D; D_SOD123_axial
D_F1, D_F2, D_F3, D_F4, D_F5, D_F6, D_F7: D; D_SOD123_axial
D_FN1: D; D_SOD123_axial
D_G1: D; D_SOD123_axial
D_MENU1: D; D_SOD123_axial
D_META1: D; D_SOD123_axial
D_Q1: D; D_SOD123_axial
D_QB1: D; D_SOD123_axial
D_R1: D; D_SOD123_axial
D_S1: D; D_SOD123_axial
D_SHIFT1: D; D_SOD123_axial
D_T1: D; D_SOD123_axial
D_TAB1: D; D_SOD123_axial
D_TF1: D; D_SOD123_axial
D_V1: D; D_SOD123_axial
D_W1: D; D_SOD123_axial
D_X1: D; D_SOD123_axial
D_Z1: D; D_SOD123_axial
IC0: SPARKFUN_PRO_MICRO
IC1, IC2: SN75179BDRG4; SOP-8_3.9x4.9mm_P1.27mm; Mouser Part Number 595-SN65LBC179P
J1, J2: RJ45; RJ45_SMD_MJ88_HLSV6
K_1, K_2, K_3, K_4, K_5, K_6, K_7, K_8, K_9: KEYSW; MX-1U-Reversible
K_A1: KEYSW; MX-1U-Reversible
K_ALT1: KEYSW; MX-1U-Reversible
K_B1: KEYSW; MX-1U-Reversible
K_BS1: KEYSW; MX-1.75U-Reversible
K_C1: KEYSW; MX-1U-Reversible
K_CONTROL1: KEYSW; MX-1.5U-Reversible
K_D1: KEYSW; MX-1U-Reversible
K_DEL1: KEYSW; MX-1.5U-Reversible
K_E1: KEYSW; MX-1U-Reversible
K_ENTER1: KEYSW; MX-1.25U-Reversible
K_ESC1: KEYSW; MX-1U-Reversible
K_F0, K_F1, K_F2, K_F3, K_F4, K_F5, K_F6: KEYSW; MX-1U-Reversible
K_FN1: KEYSW; MX-1U-Reversible
K_G1: KEYSW; MX-1U-Reversible
K_MENU1: KEYSW; MX-1U-Reversible
K_META1: KEYSW; MX-1U-Reversible
K_Q1: KEYSW; MX-1U-Reversible
K_QB1: KEYSW; MX-1U-Reversible
K_R1: KEYSW; MX-1U-Reversible
K_S1: KEYSW; MX-1U-Reversible
K_SHIFT1: KEYSW; MX-1.75U-Reversible
K_SPACE1: KEYSW; MX-2U-Reversible
K_T1: KEYSW; MX-1U-Reversible
K_TAB1: KEYSW; MX-1.25U-Reversible
K_TF1: KEYSW; MX-1U-Reversible
K_V1: KEYSW; MX-1U-Reversible
K_W1: KEYSW; MX-1U-Reversible
K_X1: KEYSW; MX-1U-Reversible
K_Z1: KEYSW; MX-1U-Reversible
RT1, RT2: R120; D_DO-35_SOD27_P10.16mm_Horizontal
SW_RESET1: SW_PUSH; SW_TACT_TH_HORIZ_LOW

Connections:
A: IC1.8 (A), J1.1
A2: IC1.6 (Z), IC2.8 (A), J1.3, J2.6, RT1.1
B: IC1.7 (B), J1.2
B2: IC2.7 (B), J2.3
GND: D1.1 (GND), D2.1 (GND), IC0.3 (GND), IC0.4 (GND), IC0.23 (GND), IC1.4 (GND), IC2.4 (GND), J1.7, J1.8, J2.7, J2.8, SW_RESET1.1
unnamed: D_1.2 (A), K_1.2
unnamed: D_2.2 (A), K_2.2
unnamed: D_3.2 (A), K_3.2
unnamed: D_4.2 (A), K_4.2
unnamed: D_5.2 (A), K_5.2
unnamed: D_6.2 (A), K_6.2
unnamed: D_7.2 (A), K_7.2
unnamed: D_8.2 (A), K_8.2
unnamed: D_9.2 (A), K_9.2
unnamed: D_10.2 (A), K_SPACE1.2
unnamed: D_A1.2 (A), K_A1.2
unnamed: D_ALT1.2 (A), K_ALT1.2
unnamed: D_B1.2 (A), K_B1.2
unnamed: D_BS1.2 (A), K_BS1.2
unnamed: D_C1.2 (A), K_C1.2
unnamed: D_CONTROL1.2 (A), K_CONTROL1.2
unnamed: D_D1.2 (A), K_D1.2
unnamed: D_DEL1.2 (A), K_DEL1.2
unnamed: D_E1.2 (A), K_E1.2
unnamed: D_ENTER1.2 (A), K_ENTER1.2
unnamed: D_ESC1.2 (A), K_ESC1.2
unnamed: D_F1.2 (A), K_F1.2
unnamed: D_F2.2 (A), K_F2.2
unnamed: D_F3.2 (A), K_F3.2
unnamed: D_F4.2 (A), K_F4.2
unnamed: D_F5.2 (A), K_F0.2
unnamed: D_F6.2 (A), K_F5.2
unnamed: D_F7.2 (A), K_F6.2
unnamed: D_FN1.2 (A), K_FN1.2
unnamed: D_G1.2 (A), K_G1.2
unnamed: D_MENU1.2 (A), K_MENU1.2
unnamed: D_META1.2 (A), K_META1.2
unnamed: D_Q1.2 (A), K_Q1.2
unnamed: D_QB1.2 (A), K_QB1.2
unnamed: D_R1.2 (A), K_R1.2
unnamed: D_S1.2 (A), K_S1.2
unnamed: D_SHIFT1.2 (A), K_SHIFT1.2
unnamed: D_T1.2 (A), K_T1.2
unnamed: D_TAB1.2 (A), K_TAB1.2
unnamed: D_TF1.2 (A), K_TF1.2
unnamed: D_V1.2 (A), K_V1.2
unnamed: D_W1.2 (A), K_W1.2
unnamed: D_X1.2 (A), K_X1.2
unnamed: D_Z1.2 (A), K_Z1.2
RX-: IC0.2 (RXI), IC1.2 (R), IC2.2 (R)
SCL: D1.3 (SCL), D2.3 (SCL), IC0.6 (*3)
SDA: D1.4 (SDA), D2.4 (SDA), IC0.5 (2)
TX+: IC0.1 (TXO), IC1.3 (D), IC2.3 (D)
VCC: IC0.21 (VCC)
VUSB: D1.2 (VCC), D2.2 (VCC), IC0.24 (RAW), IC1.1 (VCC), IC2.1 (VCC), J1.4, J1.5, J2.4, J2.5
Y: IC1.5 (Y), J1.6, RT1.2
Y2: IC2.5 (Y), J2.1, RT2.1
Z2: IC2.6 (Z), J2.2, RT2.2
col0: IC0.7 (4), K_CONTROL1.1, K_ESC1.1, K_F1.1, K_FN1.1, K_SHIFT1.1, K_TAB1.1
col1: IC0.8 (*5), K_1.1, K_A1.1, K_ALT1.1, K_F2.1, K_Q1.1, K_Z1.1
col2: IC0.9 (*6), K_2.1, K_F3.1, K_META1.1, K_S1.1, K_W1.1, K_X1.1
col3: IC0.10 (7), K_3.1, K_C1.1, K_D1.1, K_E1.1, K_F4.1, K_TF1.1
col4: IC0.20 (A3), K_4.1, K_F0.1, K_F5.1, K_QB1.1, K_R1.1, K_V1.1
col5: IC0.19 (A2), K_5.1, K_B1.1, K_F6.1, K_G1.1, K_MENU1.1, K_T1.1
col6: IC0.18 (A1), K_6.1, K_7.1, K_8.1, K_9.1, K_SPACE1.1
col7: IC0.17 (A0), K_BS1.1, K_DEL1.1, K_ENTER1.1
reset: IC0.22 (RESET), SW_RESET1.2
row0: D_1.1 (K), D_2.1 (K), D_3.1 (K), D_4.1 (K), D_5.1 (K), D_6.1 (K), D_BS1.1 (K), D_ESC1.1 (K), IC0.16 (13(SCK))
row1: D_7.1 (K), D_DEL1.1 (K), D_E1.1 (K), D_Q1.1 (K), D_R1.1 (K), D_T1.1 (K), D_TAB1.1 (K), D_W1.1 (K), IC0.14 (11(MOSI))
row2: D_8.1 (K), D_A1.1 (K), D_CONTROL1.1 (K), D_D1.1 (K), D_ENTER1.1 (K), D_F5.1 (K), D_G1.1 (K), D_S1.1 (K), IC0.15 (12(MISO))
row3: D_9.1 (K), D_B1.1 (K), D_C1.1 (K), D_SHIFT1.1 (K), D_V1.1 (K), D_X1.1 (K), D_Z1.1 (K), IC0.11 (8)
row4: D_10.1 (K), D_ALT1.1 (K), D_FN1.1 (K), D_MENU1.1 (K), D_META1.1 (K), D_QB1.1 (K), D_TF1.1 (K), IC0.12 (*9)
row5: D_F1.1 (K), D_F2.1 (K), D_F3.1 (K), D_F4.1 (K), D_F6.1 (K), D_F7.1 (K), IC0.13 (*10)

Notes on the sheet:
这绝对很奇怪啊喵！
RJ45 Cross: 1 (A) -> Y2 2 (B) -> Z2 3 (Z) -> B2 6 (Y) -> A2

Board: 2 copper layers, 190.6 x 152.5 mm, 98 parts (4 on the bottom side), 72 nets.

## Commit log

2020-06-14 Add Splite Keyboard v2 KiCad design.
2020-06-14 Add product pcb outputs.
2020-06-14 Update Current Project.
2020-06-14 Fix image embbed.
2020-06-14 Add license link.
2020-06-14 New layout deign begin!
2020-06-27 Add output files for v3 design.
    Update readme.
2020-06-27 Add zh_CN README.md.
2020-06-27 Add parts list.
